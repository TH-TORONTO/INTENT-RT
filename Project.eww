<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\INTEN_KERASTF_STM767_App-Dl-Intent-Rt.ewp</path>
  </project>
  <batchBuild />
</workspace>
